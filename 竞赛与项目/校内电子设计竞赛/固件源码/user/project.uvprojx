# Keil uVision project project.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ..\user;..\code;..\ml_libs;..\m0_sdk\source;..\m0_sdk\source\third_party\CMSIS\Core\Include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: ../m0_sdk/source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/driverlib.a
  group user
    ./: main.c startup_mspm0g350x_uvision.s isr.c ti_msp_dl_config.c ti_msp_dl_config.h encoder.c encoder.h serical.c seriacl.h track.c track.h buzzer_light.c buzzer_light.h xunji.c xunji.h key.c key.h hcsr04.c hcsr04.h
    ../m0_sdk/source/ti/devices/msp/m0p/: mspm0g350x.h
  group code
    ./: IMU.c IMU.h _pid.c _pid.h
  group ml_libs
    ../ml_libs/: headfile.h ml_gpio.c ml_gpio.h ml_tim.c ml_tim.h ml_uart.c ml_uart.h ml_delay.c ml_delay.h ml_system.c ml_system.h ml_pwm.c ml_pwm.h ml_oled.c ml_oled.h ml_oled_font.h ml_i2c.c ml_i2c.h ml_mpu6050.c ml_mpu6050.h ml_exti.c ml_exti.h ml_motor.c ml_motor.h
